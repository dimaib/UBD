# Repository dimaib/UBD

File README.md:

# Wireless access device
## Description
This system allows you to distribute people between warehouse equipment and give permission to control certain types of machines. It also allows you to take into account the working hours of employees and conduct convenient analytics according to these hours.
- The system consists of a device that controls the warehouse machine directly
	>The printed circuit board and circuit diagram of the device are created in [KiCad](https://www.kicad.org) 
	Firmware created in Keil uVision for ARM in C languages
- Server that receives data from devices and adds this data to the database
	>The server part was created in Visual Studio C ++, as a console application
- Client application that connects to the database and in a convenient form, displays
	>The client application was created in Visual Studio C#, as an application with a user interface

## KiCad design schematic_pcb/UBD_stm32/UBD.kicad_pcb

Parts:
C1: 100uF; C_Radial_D12.5mm_H20.0mm_P5.00mm
C2, C4, C5: 100n; C_0603_1608Metric
C3, C7: 220uF; CP_Elec_8x10.5
C6, C12, C13: 1uF; C_0603_1608Metric
C8: 10uF; C_0603_1608Metric
C9: 0.01uF; C_0603_1608Metric
C10: 22uF; C_0603_1608Metric
C11: 1000pF; C_0603_1608Metric
D1, D2, D3, D5, D6: Диод Шоттки; D_SMA
D4: LED; LED_0805_2012Metric
D7: Светодиод красный; LED_D3.0mm_Horizontal_O1.27mm_Z2.0mm
D8: Светодиод жёлтый; LED_D3.0mm_Horizontal_O1.27mm_Z2.0mm
D9: Светодиод зелёный; LED_D3.0mm_Horizontal_O1.27mm_Z2.0mm
D10: Светодиод синий; LED_D3.0mm_Horizontal_O1.27mm_Z2.0mm
D11: SP0503; SOT-143
D12: LIS3DHTR; LGA-16_3x3mm_P0.5mm_LayoutBorder3x5y
D15, D16: Диод Шоттки; D_SOT-23_ANK
F1: Fuse; R_1206_3216Metric
J1: ST-Link; JST_XH_S5B-XH-A_1x05_P2.50mm_Horizontal
J2: Ignition; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J3: Считыватель; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
J4: USB_B_Micro; USB_Mini-B_Lumberg_2486_01_Horizontal
J5: Turtle; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J6: Удар; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J7: Питание; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
K1, K2: NRP-18; Relay_NRP-18
L2: 1500uH; SDR_1006
L3: 10uH; L_Vishay_IHLP-2525
Q1, Q2: BC817; SOT-23
R1, R9, R10: 360; R_0603_1608Metric
R2, R4, R5, R6, R7, R8, R11, R12, R13, R25: 10k; R_0603_1608Metric
R3: 330; R_Array_Convex_4x0603
R22: 100k; R_0603_1608Metric
R23: 1.6k; R_0603_1608Metric
R24: 30k; R_0603_1608Metric
SW1, SW2: SW_DIP_x06; SW_DIP_SPSTx06_Slide_Omron_A6H-6101_W6.15mm_P1.27mm
U1: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
U2: LM2576HVS-12; TO-263-5_TabPin3
U3: ESP-12F; ESP-12E
U4: CP2102; QFN-28-1EP_5x5mm_P0.5mm_EP3.35x3.35mm
U5: AT24CS256; SOIC-8_3.9x4.9mm_P1.27mm
U9: LM2734Y; TSOT-23-6
Y1: 8.0MHz; Crystal_SMD_3225-2Pin_3.2x2.5mm_HandSoldering

Connections:
+3V3: C6.1, C7.1, C10.2, C11.2, C12.1, C13.1, D12.1, D12.8, D12.14, D16.2 (A), J1.2, J6.4, L3.2, R1.2, R2.1, R4.1, R7.2, R8.2, R11.1, R12.2, R13.2, R23.1, U1.9 (VDDA), U1.24 (VDD), U1.36 (VDD), U1.48 (VDD), U3.8 (VCC), U4.6 (VDD), U5.8 (VCC)
+5V: D2.1 (K), D11.4 (K), U4.7 (REGIN), U4.8 (VBUS)
+12V: C3.1, C8.2, D5.1 (K), D6.1 (K), J3.2, K1.2, K2.2, L2.2, R22.1, U2.4 (FB), U9.5 (VIN)
/CLK: J1.4, U1.37 (PA14)
/Data0: J3.3, R4.2, U1.16 (PA6)
/Fb: C11.1, R24.1, R25.2, U9.3 (FB)
/Ig: R10.2, U1.15 (PA5)
/Ig_NO1: J2.2, K1.1
/Ig_NO2: J2.1, K1.3
/Led1: D7.2 (A), U1.41 (PB5)
/Led2: D8.2 (A), U1.45 (PB8)
/Led3: D9.2 (A), U1.46 (PB9)
/Led4: D10.2 (A), U1.2 (PC13)
/RXD: U1.30 (PA9), U4.25 (RXD)
/RX_W: U1.12 (PA2), U3.21 (GPIO3/RXD)
/Rst: C5.1, R2.2, U1.7 (NRST)
/Rst_wf: R7.1, U1.11 (PA1), U3.1 (~RST)
/SCL: D12.4, R13.1, U1.42 (PB6), U5.6 (SCL)
/SDA: D12.6, R12.1, U1.43 (PB7), U5.5 (SDA)
/SWD: J1.3, U1.34 (PA13)
/SWO: J1.1, U1.39 (PB3)
/TXD: U1.31 (PA10), U4.26 (TXD)
/TX_W: U1.13 (PA3), U3.22 (GPIO1/TXD)
/Tr: R9.1, U1.14 (PA4)
/Tr_NO1: J5.2, K2.1
/Tr_NO2: J5.1, K2.3
/Tx_ud: J6.2, U1.21 (PB10)
/Udar: J6.3, U1.22 (PB11)
/bit0: SW1.1, U1.32 (PA11)
/bit1: SW1.2, U1.33 (PA12)
/bit2: SW1.3, U1.29 (PA8)
/bit3: SW1.4, U1.28 (PB15)
/bit4: SW1.5, U1.27 (PB14)
/bit5: SW1.6, U1.26 (PB13)
/bit6: SW2.1, U1.25 (PB12)
/bit7: SW2.2, U1.19 (PB1)
/bit8: SW2.3, U1.18 (PB0)
/bit9: SW2.4, U1.17 (PA7)
/bit10: SW2.5, U1.40 (PB4)
/bit11: SW2.6, U1.38 (PA15)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C10.1, C12.2, C13.2, D3.2 (A), D4.1 (K), D11.1 (A), D12.2, D12.3, D12.5, D12.7, D12.10, D12.12, D12.13, D12.15, D12.16, D15.2 (A), J1.5, J3.1, J4.5, J4.6, J6.1, J7.1, Q1.2 (E), Q2.2 (E), R3.5 (R4.2), R3.6 (R3.2), R3.7 (R2.2), R3.8 (R1.2), R5.2, R6.2, R25.1, SW1.7, SW1.8, SW1.9, SW1.10, SW1.11, SW1.12, SW2.7, SW2.8, SW2.9, SW2.10, SW2.11, SW2.12, U1.8 (VSSA), U1.23 (VSS), U1.35 (VSS), U1.47 (VSS), U2.3 (GND), U2.5 (~ON~/OFF), U3.15 (GND), U3.16 (GPIO15), U4.3 (GND), U4.29 (GND), U5.1 (A0), U5.2 (A1), U5.3 (A2), U5.4 (GND), U5.7 (WP), U9.2 (GND); also elsewhere on the board
unnamed: C1.1, D1.1 (K), U2.1 (VIN)
unnamed: C2.1, U1.6 (PD1), Y1.1
unnamed: C4.1, U1.5 (PD0), Y1.2
unnamed: C9.1, D15.1 (K), L3.1, U9.6 (SW)
unnamed: C9.2, D16.1 (K), U9.1 (BOOST)
unnamed: D1.2 (A), F1.1
unnamed: D2.2 (A), J4.1
unnamed: D3.1 (K), L2.1, U2.2 (OUT)
unnamed: D4.2 (A), R1.1
unnamed: D5.2 (A), K1.5, Q1.3 (C)
unnamed: D6.2 (A), K2.5, Q2.3 (C)
unnamed: D7.1 (K), R3.4 (R4.1)
unnamed: D8.1 (K), R3.3 (R3.1)
unnamed: D9.1 (K), R3.2 (R2.1)
unnamed: D10.1 (K), R3.1 (R1.1)
unnamed: D11.2 (K), J4.2, U4.5 (D-)
unnamed: D11.3 (K), J4.3, U4.4 (D+)
unnamed: F1.2, J7.2
unnamed: Q1.1 (B), R10.1
unnamed: Q2.1 (B), R9.2
unnamed: R5.1, U1.44 (BOOT0)
unnamed: R6.1, U1.20 (PB2)
unnamed: R8.1, U3.3 (EN)
unnamed: R11.2, U4.9 (~RSTb)
unnamed: R22.2, U9.4 (EN)
unnamed: R23.2, R24.2

Notes on the sheet:
Gnd
CLK
SWD
3v3
SWO
i2c addresss 0x30
i2c addresss 0x50

Board: 2 copper layers, 95.5 x 67.0 mm, 70 parts (6 on the bottom side), 67 nets.

Other parts of the board:
GND: PinHeader_1x01_P2.54mm_Vertical
GND#2, GND#3: PinHeader_1x01_P2.54mm_Vertical

Their connections:
GND: GND.1, GND#2.1, GND#3.1; also elsewhere on the board

## KiCad design 04. RFID_USB_carta/Схема и ПП/USB_RFID/USB_RFID.kicad_pcb

Parts:
C1: 10uF 10V; CP_EIA-3216-18_Kemet-A
C2, C3: 33pF; C_0805_2012Metric
D1, D2: 3v6; D_MiniMELF
D3: LED; LED_0603_1608Metric
J1: К RFID-считывателю; USB
J2: Разъём программирования; PinHeader_2x03_P2.54mm_Vertical
J3: USB кабель; RFID
R1, R6: 10k; R_0603_1608Metric
R2, R3: 68; R_0603_1608Metric
R4: 1.5k; R_0603_1608Metric
R5: 360; R_0603_1608Metric
SW1: SW_Push; SW_SPST_PTS645
U1: ATmega8-16AU; TQFP-32_7x7mm_P0.8mm
Y1: 12MHz; Crystal_SMD_HC49-SD_HandSoldering

Connections:
+5V: C1.1, J1.1, J2.6, J3.1, R1.1, R4.1, R6.1, U1.4 (VCC), U1.6 (VCC), U1.18 (AVCC), U1.20 (AREF)
/1wire: J1.3, R6.2, U1.25 (PC2)
/Mis: J2.1, U1.16 (PB4)
/Mod: SW1.1, U1.30 (PD0)
/Mos: J2.5, U1.15 (PB3)
/Res: J2.3, R1.2, U1.29 (PC6/~RESET)
/Sck: J2.2, U1.17 (PB5)
GND: C1.2, C2.2, C3.2, D1.2 (A), D2.2 (A), D3.1 (K), J1.2, J2.4, J3.4, SW1.2, U1.3 (GND), U1.5 (GND), U1.21 (AGND)
unnamed: C2.1, U1.8 (PB7/XTAL2), Y1.1
unnamed: C3.1, U1.7 (PB6/XTAL1), Y1.2
unnamed: D1.1 (K), J3.3, R3.1, R4.2
unnamed: D2.1 (K), J3.2, R2.1
unnamed: D3.2 (A), R5.1
unnamed: R2.2, U1.32 (PD2)
unnamed: R3.2, U1.2 (PD4)
unnamed: R5.2, U1.26 (PC3)

Notes on the sheet:
Vcc (Красный)
D+ (Зелёный)
D- (Белый)
Gnd (Чёрный)
1Wire (Жёлтый)
Gnd (Белый)
Vcc (Коричневый)

Board: 2 copper layers, 37.0 x 79.4 mm, 18 parts (0 on the bottom side), 16 nets.

## KiCad design schematic_pcb/Accel/cad/Accel.kicad_pcb

Parts:
C1: 1uF; C_0805_2012Metric
C2, C3: 10uF; CP_EIA-3216-18_Kemet-A
C4: 1000pF; C_0603_1608Metric
D1, D2: LED; LED_0805_2012Metric
D3: LED; LED_D3.0mm_Horizontal_O1.27mm_Z6.0mm
D4, D7: AZ23c3v3; SOT-23
D5: BAS321.115; D_SOD-323_HandSoldering
D6: G404020B; //www.chipdip.ru/product/g404020b
J1: Conn_02x03_Counter_Clockwise; PinHeader_2x03_P2.54mm_Vertical
J2: Conn_01x04; DG308_04
J3: Conn_01x02; DG308_02
L1: 47uH; L_1812_4532Metric
Q1: BC817; SOT-23
R1, R2, R6, R11, R12: 10k; R_0603_1608Metric
R3, R4, R5, R7: 360; R_0603_1608Metric
R8: 1k; R_0603_1608Metric
R9: 22k; R_0603_1608Metric
R10: 100k; R_0603_1608Metric
R13: 330; R_0805_2012Metric
U1: LIS302; LGA-14_3x5mm_P0.8mm_LayoutBorder1x6y
U2: ATmega8A; TQFP-32_7x7mm_P0.8mm
U4: LMV321; SOT-23-5

Connections:
+3V3: D4.1, D4.3, R1.1, R2.1, R6.1, R12.2, R13.2, U1.1 (Vcc), U1.3 (Vcc), U1.6 (Vcc), U1.7 (CS), U2.4 (VCC), U2.6 (VCC), U2.18 (AVCC), U2.20 (AREF), U4.5 (V+)
+5V: C1.1, C2.1, J1.6, J2.3, L1.1
/Mis: J1.1, U2.16 (PB4)
/Mos: J1.5, U2.15 (PB3)
/Res: J1.3, R6.2, U2.29 (PC6/~RESET)
/Rx: J2.1, R12.1, U2.30 (PD0)
/SCL: R1.2, U1.14 (SCL), U2.27 (PC4)
/SDA: R2.2, U1.13 (SDA), U2.28 (PC5)
/Sck: J1.2, U2.17 (PB5)
/Speed: C4.1, R9.2, U2.12 (PB0), U4.4
/Udar: J2.2, Q1.3 (C)
GND: C1.2, C2.2, C3.2, C4.2, D3.1 (K), D4.2, D7.2, J1.4, J2.4, J3.1, Q1.2 (E), R3.2, R4.2, R8.2, R11.2, U1.2 (Gnd), U1.4 (Gnd), U1.5 (Gnd), U1.10 (Gnd), U1.11 (Gnd), U2.3 (GND), U2.5 (GND), U2.21 (AGND), U4.2 (V-)
unnamed: C3.1, L1.2, R13.1
unnamed: D1.1 (K), R4.1
unnamed: D1.2 (A), U1.9 (int2)
unnamed: D2.1 (K), R3.1
unnamed: D2.2 (A), U1.8 (int1)
unnamed: D3.2 (A), R7.1
unnamed: D5.1 (A), J3.2
unnamed: D5.2 (K), R10.1
unnamed: D7.1, D7.3, R10.2, R11.1, U4.1 (+)
unnamed: Q1.1 (B), R5.1
unnamed: R5.2, U2.32 (PD2)
unnamed: R7.2, U2.13 (PB1)
unnamed: R8.1, R9.1, U4.3 (-)

Board: 2 copper layers, 30.4 x 24.4 mm, 31 parts (0 on the bottom side), 25 nets.

## KiCad design schematic_pcb/UBD/cad_RFID+Плата/UBD.kicad_pcb

Board: 2 copper layers, 72.0 x 102.5 mm, 60 parts (5 on the bottom side), 69 nets.

Parts:
C1: 100; C_Radial_D8.0mm_H11.5mm_P3.50mm
C2, C3: 220; CP_Elec_8x10.5
C4, C5, C6: 1uF; C_0805_2012Metric
C7: 100nF; C_0805_2012Metric
D1, D2, D3: D_Schottky; D_SMA
D4: LED; LED_0805_2012Metric
D5, D6: D_Schottky; D_DO-41_SOD81_P7.62mm_Horizontal
D7, D8, D9, D10: Red; LED_D3.0mm_Horizontal_O1.27mm_Z2.0mm
D12, D13: Red; LED_0805_2012Metric
F1: Fuse; R_1206_3216Metric
J1: Для программирования; PinHeader_2x03_P2.54mm_Horizontal
J2: Входной клемник; DG_381_9
J3: Считыватель; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J4: USB_B_Micro; USB_Micro
J5: На релейной плате; PinSocket_2x06_P2.54mm_Vertical
J6: На основной плате; PinHeader_2x06_P2.54mm_Vertical
K1, K2: G5LE-1; Relay_SPDT_Omron-G5LE-1
L1: 1000; L_10.4x10.4_H4.8
L2: 2200; L_10.4x10.4_H4.8
Q1, Q2, Q3, Q4: BC817; SOT-23
R1, R7, R8, R9, R10, R11, R12, R15: 360; R_0603_1608Metric
R2, R4, R5, R6, R14, R16: 10k; R_0603_1608Metric
R3: 360; R_Array_Convex_4x0603
R13: 1k; R_0603_1608Metric
SW1: Выбор адреса; SW_DIP_SPSTx08_Slide_Omron_A6H-8101_W6.15mm_P1.27mm
U1: LM2576HVS-3.3; TO-263-5_TabPin3
U2: LM2576HVS-12; TO-263-5_TabPin3
U3: ESP-12F; ESP-12E
U4: ATmega128-16AU; TQFP-64_14x14mm_P0.8mm
U5: LIS302; LGA-14_3x5mm_P0.8mm_LayoutBorder1x6y
U6: CH340G; SOIC-16_3.9x9.9mm_P1.27mm
U7: AP1117-33; SOT-223-3_TabPin2
Y1: 14.7456MHz; Crystal_SMD_HC49-SD
Y2: 12MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm_HandSoldering

Connections:
+3V3: C2.1, C4.1, C5.1, C6.1, J1.6, J2.8, L1.2, R1.2, R2.1, R4.1, R5.1, R6.1, R7.2, R8.2, U1.4, U3.8, U4.21, U4.52, U4.62, U4.64, U5.1, U5.3, U5.6, U5.7, U6.4, U6.16, U7.2
+5V: J4.1, R15.1, U7.3
+12V: C3.1, J3.2, J6.6, J6.7, L2.2, R13.1, R14.2, U1.1, U2.4
/+12_Rel: D5.1, D6.1, J5.6, J5.7, K1.2, K2.2
/+Vin: F1.2, J2.2
/Data0: J3.3, R4.2, U4.51
/Ig: D5.2, J5.5, K1.5
/Ig_NO1: J2.3, J6.4, J6.9
/Ig_NO2: J2.4, J6.3, J6.10
/Ig_NO_1: J5.4, J5.9, K1.1
/Ig_NO_2: J5.3, J5.10, K1.3
/Igg: J6.5, Q1.3
/Mis: J1.1, U4.3, U6.3
/Mos: J1.5, U4.2, U6.2
/RXD: U3.21, U4.28
/Rst: C7.1, J1.3, R2.2, U4.20
/Rst_wf: R7.1, U3.1, U4.29
/SCL: R5.2, U4.18, U5.14
/SDA: R6.2, U4.16, U5.13
/Sck: J1.2, U4.11
/TXD: U3.22, U4.27
/Tr: D6.2, J5.8, K2.5
/Tr_NO1: J2.6, J6.2, J6.11
/Tr_NO2: J2.5, J6.1, J6.12
/Tr_NO_1: J5.2, J5.11, K2.1
/Tr_NO_2: J5.1, J5.12, K2.3
/Trr: J6.8, Q2.3
/Udar: J2.9, U4.19
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, D2.2, D3.2, D4.1, D7.1, D8.1, D9.1, D10.1, J1.4, J2.1, J2.7, J3.1, J4.5, Q1.2, Q2.2, Q3.2, Q4.2, R11.1, R12.1, R16.2, SW1.9, SW1.10, SW1.11, SW1.12, SW1.13, SW1.14, SW1.15, SW1.16, U1.3, U2.3, U2.5, U3.15, U3.16, U4.22, U4.53, U4.63, U5.2, U5.4, U5.5, U5.10, U5.11, U6.1, U7.1
unnamed: C1.1, D1.1, U2.1
unnamed: C7.2, U6.10
unnamed: D1.2, F1.1
unnamed: D2.1, L1.1, U1.2
unnamed: D3.1, L2.1, U2.2
unnamed: D4.2, R1.1
unnamed: D7.2, R3.8
unnamed: D8.2, R3.7
unnamed: D9.2, R3.6
unnamed: D10.2, R3.5
unnamed: D12.1, R11.2
unnamed: D12.2, U5.9
unnamed: D13.1, R12.2
unnamed: D13.2, U5.8
unnamed: J4.2, U6.6
unnamed: J4.3, U6.5
unnamed: Q1.1, R9.2
unnamed: Q2.1, R10.1
unnamed: Q3.1, Q4.3, R13.2
unnamed: Q3.3, R14.1, U1.5
unnamed: Q4.1, R15.2, R16.1
unnamed: R3.1, U4.48
unnamed: R3.2, U4.47
unnamed: R3.3, U4.46
unnamed: R3.4, U4.45
unnamed: R8.1, U3.3
unnamed: R9.1, U4.14
unnamed: R10.2, U4.25
unnamed: SW1.1, U4.35
unnamed: SW1.2, U4.36
unnamed: SW1.3, U4.37
unnamed: SW1.4, U4.38
unnamed: SW1.5, U4.39
unnamed: SW1.6, U4.40
unnamed: SW1.7, U4.41
unnamed: SW1.8, U4.42
unnamed: U4.23, Y1.1
unnamed: U4.24, Y1.2
unnamed: U6.7, Y2.2
unnamed: U6.8, Y2.1

## Commit log

2022-04-16 add RFID_READ
2022-04-17 del Major
2022-04-17 del programm usb_hid
2022-04-19 add readme.md
2022-04-19 edit readme.md
2022-04-20 add screen
2022-04-20 edit screen
